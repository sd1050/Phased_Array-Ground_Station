<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>snr_calc</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/mnt/c/Users/sd1050/Desktop/Ground_Station/Phased_Array-Ground_Station/sync-stream2-2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>msg_nsamples</key><value>10000</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>filename</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>sync-stream2-2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
</flow_graph>
